# IAR project handle.ewp, settings and files
configuration handle (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Src\simplelib; ../Src\simplelib\can; ../Src\simplelib\cmd; ../Src\simplelib\core; ../Src\simplelib\flash; ../Src\simplelib\nrf; ../Src\simplelib\utils; ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: handle.hex
  ILINK.IlinkOutputFile: handle.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: adc.c adc_func.c can.c dma.c fsmc.c gpio.c ILI93xx.c lcd_func.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c sys.c usart.c
  group Application/User/simplelib
    ../Src/simplelib/can/: can_func.c can_func.h can_utils.c can_utils.h
    ../Src/simplelib/cmd/: cmd.c cmd.h cmd_func.c cmd_func.h
    ../Src/simplelib/core/: flags.c flags.h
    ../Src/simplelib/flash/: flash.c flash.h stmflash.c stmflash.h
    ../Src/simplelib/utils/: hash.c hash.h utils.c utils.h
    ../Src/simplelib/nrf/: nrf24l01.c nrf24l01.h nrf_comm.c nrf_comm.h
    ../Src/simplelib/: simplelib.c simplelib.h simplelib_cfg.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c
